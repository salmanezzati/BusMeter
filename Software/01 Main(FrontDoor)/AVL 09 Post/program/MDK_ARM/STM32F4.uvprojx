# Keil uVision project STM32F4.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Security_Alarm_System +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\STM32F4xx;..\STM32F4xx\STM32F4xx_StdPeriph_Driver\inc;..\;..\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../src/: main.c
  group stm32f4xx
    ./: startup_stm32f4xx.s
    ../src/: delay.c lcd.c usart.c stm32f4xx_it.c system_stm32f4xx.c diskio.c exti.c ff.c gpio.c rtc.c sd_bmp.c stm32f4_sdio_low_level_init.c stm32f4_sdio_sd.c tim.c sim808.c stm32f4xx_mfrc522.c SDIO.c
  group StdPeriph_Driver
    ../STM32F4xx/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_exti.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_pwr.c stm32f4xx_dma.c
software components: CMSIS:CORE 5.1.2
